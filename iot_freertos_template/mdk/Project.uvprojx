# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\app;..\driver;..\fireware\cmsis\core;..\fireware\cmsis\device;..\fireware\driver\inc;..\third_lib\freertos\include;..\third_lib\freertos\portable\RVDS\ARM_CM3;..\third_lib\cjson;..\third_lib\mqtt;..\third_lib\onenet\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.h main.c FreeRTOSConfig.h my_tasks.h task_led.c task_net.c task_sensor.c
  group driver
    ../driver/: delay.h delay.c timer.h timer.c led.h led.c esp8266.h esp8266.c i2c.h i2c.c oled.h oled.c oled_data.h oled_data.c dht11.h dht11.c uart.c uart.h
  group fireware
    ../fireware/cmsis/core/: core_cm3.c core_cm3.h
    ../fireware/cmsis/device/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s
    ../fireware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group third_lib/onenet
    ../third_lib/onenet/src/: base64.c hmac_sha1.c onenet.c
  group third_lib/mqtt
    ../third_lib/mqtt/: MqttKit.c
  group third_lib/cjson
    ../third_lib/cjson/: cJSON.c
  group third_lib/freertos
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/freertos/portable/MemMang/: heap_4.c
    ../third_lib/freertos/portable/RVDS/ARM_CM3/: port.c portmacro.h
